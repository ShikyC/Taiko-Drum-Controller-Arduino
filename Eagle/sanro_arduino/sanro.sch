File: Eagle/sanro_arduino/sanro.sch (EAGLE design)
At the start: 5 parts

Commit message: Upload EPS file for the PCB
Parts:
- renumbered SV1 to LD, SV2 to RD, SV3 to LK, SV4 to RK
